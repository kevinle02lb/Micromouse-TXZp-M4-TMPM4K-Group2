# Keil uVision project toshibaMicromouse.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: TMPM4KNF10AFG Toshiba
  pack: Toshiba.TXZ4Aplus-M4K2_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: toshibaMicromouse
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: TMPM4KNA
  c include: ..\src\modules;..\src\drivers;..\src;..\vendor\cmsis\Include;..\vendor\toshiba\Include;..\vendor\toshiba\Source
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: C:\Keil_v5\Kiel_Arm_Pack\Toshiba\TXZ4Aplus-M4K2_DFP\1.0.1\Device\Source\ARM\TMPM4KNA.scat
  group Source Group 1
    ../src/drivers/: timer32A.c timer32A.h encoder32A.c gpio.c adc.c dma.c systick.c uart.c
    ../src/modules/: Encoder.c FloodFill.c IrSensor.c Motion.c Motor.c Navigator.c Odometry.c PID.c Timebase.c Profile.c
    ../src/: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
